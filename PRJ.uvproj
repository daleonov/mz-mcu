# Keil uVision project PRJ.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Firmware +hex
  c flags: Optim=3
  c define: USE_STDPERIPH_DRIVER
  c include: .\CMSIS\CM3\CoreSupport;.\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\STM32F10x_StdPeriph_Driver\inc;.\User\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ./Startup/: startup_stm32f10x_hd_vl.s
  group CMSIS
    ./CMSIS/CM3/CoreSupport/: core_cm3.c
    ./CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group User
    ./User/: MCU_Main.c MCU_MarkZeroBsp.c MCU_System.c MCU_Serial.c MCU_SerialFifo.c
  group STM32F10x_StdPeriph_Driver
    ./STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_flash.c stm32f10x_tim.c
